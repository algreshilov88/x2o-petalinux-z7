SRC_URI += "file://user_2022-10-25-17-50-00.cfg \
            file://user_2022-10-25-21-49-00.cfg \
            file://user_2022-10-25-22-41-00.cfg \
            file://0001-i2c-cdns-timeout-set-to-5ms-disabled-pm-timeout-adde.patch \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"



